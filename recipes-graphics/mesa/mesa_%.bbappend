PACKAGECONFIG:append:x86 = " gallium-llvm gallium r600"
PACKAGECONFIG:append:x86-64 = " gallium-llvm gallium r600"
